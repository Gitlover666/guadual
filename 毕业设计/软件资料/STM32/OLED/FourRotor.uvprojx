# Keil uVision project FourRotor.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FourRotor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\user\sys;.\user\delay;.\HARDWARE\IIC;.\HARDWARE\mpu6050;.\HARDWARE\USART;.\HARDWARE\LED;.\HARDWARE\OLED;.\HARDWARE\CAN;.\HARDWARE\key;.\HARDWARE\timer;.\HARDWARE\exit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
    ./user/delay/: delay.c
    ./user/sys/: sys.c
  group HARDWARE
    ./HARDWARE/USART/: usart.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/OLED/: OLED.c
    ./HARDWARE/CAN/: can.c
    ./HARDWARE/key/: key.c
    ./HARDWARE/timer/: timer.c
    ./HARDWARE/exit/: exit.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
